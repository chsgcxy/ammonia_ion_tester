# Keil uVision project printer.uvprojx, settings and files
target ammonia (ARM-ADS)
  device: STM32F207VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ammonia +hex
  c flags: Optim=3 uC99=1 wLevel=2
  c include: ..\core;..\lib;..\user;..\emwin\Config;..\emwin\inc;..\freertos\CMSIS_RTOS;..\freertos\include;..\freertos\portable\RVDS\ARM_CM3;..\usb\STM32_USB_HOST_Library\Core\inc;..\usb\STM32_USB_HOST_Library\Class\MSC\inc;..\usb\STM32_USB_OTG_Driver\inc;..\usb\porting;..\fatfs\inc;..\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../user/: main.c report.c ui_menu.c sysconf.c data.c ui_check.c ui_test.c ui_setting.c ui_diag_ok.c ui_numpad.c test.c
    ../driver/: touch.c
  group core
    ../core/: core_cm3.c system_stm32f2xx.c startup_stm32f2xx.s
  group stm32f2xx-lib
    ../lib/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group emwin
    ../emwin/Config/: GUIConf.c GUIDRV.c SIMConf.c LCDConf.c
    ../emwin/OS/: GUI_X_OS.c
    ../emwin/Lib/: STemWin532_CM3_OS_Keil.lib
  group freertos
    ../freertos/CMSIS_RTOS/: cmsis_os.c
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM3/: port.c
    ../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group usb-otg
    ../usb/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group usb-host
    ../usb/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../usb/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group usb-porting
    ../usb/porting/: usb_bsp.c usbh_usr.c usb_conf.h usbh_conf.h usbh_usr.h
  group fatfs
    ../fatfs/src/: fattime.c ff.c diskio.c
  group driver
    ../driver/: rd-tprinter.c ad770x.c stm32_spi.c stm32_uart.c stepmotor.c delay.c w25xxx.c beep.c ds18b20.c rtc.c ads1256.c
  group fonts
    ../fonts/: yahei_16.c yahei_20.c
  group pictures
    ../picture/: chemical_72px.c error_32px.c infor_32px.c process_running_72px.c view_72px.c warning_32px.c logo_170px.c electricplug_72px.c
